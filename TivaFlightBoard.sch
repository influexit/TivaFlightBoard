File: TivaFlightBoard.sch (EAGLE design)
At the start: 0 parts

Commit message: Added pdf file
Parts:
- added U$1: TIVALP, Tiva:TIVALP
